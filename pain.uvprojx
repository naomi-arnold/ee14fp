# Keil uVision project pain.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: pain +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./RTE/Device/STM32L476VGTx/STCubeGenerated/Src/: test.c ssd1306.c fonts.c
    ./RTE/Device/STM32L476VGTx/STCubeGenerated/Inc/: fonts.h ssd1306.h test.h
    ./: NES.c NES.h
    ../lab 4/SysTick/: LED.c LED.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 6.0.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:I2C 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:Startup 1.3.1
